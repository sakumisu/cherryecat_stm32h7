# Keil uVision project stm32h7vit6_cherryecat.uvprojx, settings and files
target stm32h7vit6_cherryecat (6240000::V6.24::ARMCLANG)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.6.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: stm32h7vit6_cherryecat +hex
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=3 wLevel=3
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H743xx
  c include: ../Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../FreeRTOS-10.4/include;../FreeRTOS-10.4/portable/GCC/ARM_CM7/r0p1;../CherryECAT/include;../CherryRB;../CherrySH
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: stm32h7vit6_cherryecat\stm32h7vit6_cherryecat.sct
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User
    ../Src/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group FREERTOS
    ../FreeRTOS-10.4/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../FreeRTOS-10.4/portable/GCC/ARM_CM7/r0p1/: port.c
    ../FreeRTOS-10.4/portable/MemMang/: heap_4.c
  group CherryECAT
    ../CherryECAT/port/: netdev_stm32h7.c
    ../CherryECAT/src/: ec_cmd.c ec_coe.c ec_common.c ec_datagram.c ec_eoe.c ec_foe.c ec_mailbox.c ec_master.c ec_netdev.c ec_sii.c ec_slave.c ec_slave_table.c ec_timestamp.c
    ../CherryECAT/src/phy/: chry_phy.c
    ../CherryECAT/osal/: ec_osal_freertos.c
  group CherrySH
    ../CherrySH/: chry_shell.c
    ../CherryRB/: chry_ringbuffer.c
    ../CherrySH/cherryrl/: chry_readline.c
    ../CherrySH/builtin/: clear.c help.c login.c shsize.c
    ../CherrySH/samples/stm32/freertos_uart/Src/: shell.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
software components: CMSIS:CORE 6.1.1
